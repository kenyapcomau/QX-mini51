# Keil uVision project qiangsheng.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(33000000) MODAT2
  output: qiangsheng +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: qiangsheng.c
